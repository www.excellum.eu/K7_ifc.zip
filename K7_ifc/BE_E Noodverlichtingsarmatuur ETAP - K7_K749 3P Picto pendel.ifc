Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-06-15T09:38:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160525_1230(x64) - Exporter 16.0.1144.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 15 09:38:43 2016 * Host: gebruiker-PC * Database: C:\Users\GEBRUI~1\AppData\Local\Temp\{E69FA152-9541-4A4B-B11E-585EA9122361}\ifc * Database version: 5507 * Database creation date: Wed Jun 15 09:38:43 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 15 09:38:43 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 15 09:38:43 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: K7H14-50, K7H14-50:K7H14-50:242401
In: Level 1
Type - Constraints - Default Elevation: 1219.2 mm
Type - Identity Data - BE_I Bestelcode: K1H4-50; Cost: 0; Description: aansluitstuk pendelmontage - horizontale armatuurmontage; Manufacturer: Etap; Model: K1; Type Name: K7H14-50
Type - Other - Category: Generic Models; Family Name: K7H14-50
Pset_BuildingElementProxyCommon - Reference: K7H14-50
Pset_ManufacturerTypeInformation - Manufacturer: Etap
Constraints - Moves With Nearby Elements: no
Construction - WT_V Pendelhoogte: 200 mm
Dimensions - Volume: 0.000218647 m3
Other - Family: K7H14-50: K7H14-50; Family and Type: K7H14-50: K7H14-50; Type: K7H14-50: K7H14-50; Type Id: K7H14-50: K7H14-50
Phasing - Phase Created: 469492

# IfcFlowTerminal: K749 3P Picto pendel, Dummy:K749 3P Picto pendel:242399
In: Level 1
Type - Material: Reflectieloze koepel, Glass, BE_DFT Referentievlak
Type - Constraints - Default Elevation: 1000 mm; WT_H Geometrie: Dubbelzijdige signalisatie; WT_H Haakse wandmontage: no; WT_H Halve breedte: 90 mm; WT_H Halve breedte negatief: -90 mm; WT_H Halve hoogte negatief: -21.5 mm; WT_H Halve lengte negatief: -157 mm; WT_H Opbouw: no; WT_H Optiek: Dubbelzijdige signalisatie; WT_H Parallelle wandmontage: no; WT_H Permanent: yes; WT_H Referentie: Pendel - verticale armatuurmontage dubbele signalisatie; WT_H Signalisatiemogelijkheden_type: enkelzijdig (E) / dubbelzijdig (D); WT_H Straal pictogram: 1.5 mm; WT_H Verschuiving pictogram wand: 0 mm
Type - Construction - WT_H Aansluitstuk: K7H14-50: K7H14-50
Type - Dimensions - BE_G Breedte: 180 mm; BE_G Hoogte: 43 mm; BE_G Lengte: 314 mm
Type - Electrical - WT_I Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 0 W
Type - Identity Data - BE_I Bestelcode: K749/3P; Cost: 0; Description: Noodverlichtingsarmatuur; Manufacturer: Etap; Model: K7; Type Name: K749 3P Picto pendel; WT_I BaseKeynote: 68.8
Type - Model Properties - WT_I Autonomie: *60; WT_I Batterij type: NiMh 1,2V 1,25Ah; WT_I Kleur: RAL9003; WT_I Lamptype: Lamp Led; WT_I Optiek: lichtgeleider; WT_I Permanent_Niet permanent: perm; WT_I Specifieke uitvoering: NVT; WT_I Uitvoering: pendel; WT_I Werking: Decentraal systeem; WT_I Zelftest: EST+
Type - Other - Category: Lighting Fixtures; Family Name: Dummy
Type - Photometrics - WT_H Lichtbron: Lichtbron K7: K749_3P_ELDZ_FOLIE; WT_I Lumen: 16
Pset_ManufacturerTypeInformation - Manufacturer: Etap
Pset_DistributionFlowElementCommon - Reference: K749 3P Picto pendel
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Code toebehoren: 0; WT_H Rotatie pictogram: 0 deg; WT_H Rotatie pictogram wand: 0 deg
Construction - WT_V Pendelhoogte: 200 mm; WT_V Upgrade Communicatie: Communicatieupgrade K7: Geen
Dimensions - Area: 0.390246 m2; Volume: 0.0122091 m3
Electrical - WT_c1 Kringnummer: 0
Electrical - Circuiting - Electrical Data: c1_Power - Balanced 230 V/1-0 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Graphics - BE_G Pictogram: BE_G_ANN Pictogram: Geen; WT_H Signalisatiemogelijkheden: enkelzijdig (E) / dubbelzijdig (D); WT_I Pictogram andere richting: no
Identity Data - Mark: 1161
Other - Family: Dummy: K749 3P Picto pendel; Family and Type: Dummy: K749 3P Picto pendel; Schedule Level: Level: Level 1; Type: Dummy: K749 3P Picto pendel; Type Id: Dummy: K749 3P Picto pendel; WT_V 3 uur autonomie: no; WT_V Lichtspotmodule: no; WT_V Uitvoering voor combinatie met E3E5 lijnsysteem_enkel voor opbouwarmaturen: no; WT_V Vluchtwegmodule: no
Phasing - Phase Created: 469492
